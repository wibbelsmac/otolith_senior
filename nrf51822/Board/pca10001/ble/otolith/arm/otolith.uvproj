# Keil uVision project otolith.uvproj, settings and files
target nRF51822_S110 (ARM-ADS)
  device: nRF51822 Nordic
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0x3FFFF) CLOCK(16000000) CPUTYPE("Cortex-M0") ESEL ELITTLE
  output: ble_app_hrs +hex
  c flags: Optim=4 oTime=1 wLevel=2
  c define: NRF51,DEBUG_NRF_USER
  c misc: --c99
  c include: ..;..\..\..\..\..\Include;..\..\..\..\..\Include\app_common;..\..\..\..\..\Include\ble;..\..\..\..\..\Include\ble\ble_services;..\..\..\..\..\Include\ble\softdevice;..\..\..\..\..\Include\util;..\..\..\..\..\Include\heart;..\..\..\..\..\Include\kiss_fft
  memory RVCT4: ROM 0x14000 size 0x2c0000
  memory RVCT9: RAM 0x20002000 size 0x2000
  group Startup Code
    ./../../../../../Source/templates/arm/: arm_startup_nrf51.s
    ./../../../../../Source/templates/: system_nrf51.c
  group Source Code
    ./../: main.c
    ../: led.c user_alarm.c motor.c rtc.c adc.c
    ../../../../../Source/dac/: dac_driver.c
    ../../../../../Source/util/: moving_avg.c util.c
  group Services
    ../../../../../Source/ble/ble_services/: ble_oto.c ble_as.c
  group Libraries
    ../../../../../Source/ble/: ble_conn_params.c ble_advdata.c ble_stack_handler.c ble_bondmngr.c ble_flash.c ble_radio_notification.c ble_error_log.c ble_debug_assert_handler.c
    ../../../../../Source/ble/ble_services/: ble_srv_common.c
    ../../../../../Source/app_common/: app_timer.c app_button.c app_gpiote.c
    ../../../../../Source/simple_uart/: simple_uart.c
    ../../../../../Source/util/: util.c
    ../../../../../Source/spi_master/: spi_master.c
    ../../../../../Source/acc/: acc_driver.c
    ../../../../../Source/step_counter/: step_counter.c
    ../../../../../Source/kiss_fft/: kiss_fft.c kiss_fftr.c
    ../../../../../Source/Heart/: pulse.c
